## dist/esp32-wifi-bootstrap_1.0.2/examples/homekit-led/sdkconfig.defaults
```kconfig
CONFIG_ESP_LED_GPIO=2
CONFIG_ESP_SETUP_CODE="111-22-333"
CONFIG_ESP_SETUP_ID="ABCD"
CONFIG_ESP_BUTTON_GPIO=0
```
